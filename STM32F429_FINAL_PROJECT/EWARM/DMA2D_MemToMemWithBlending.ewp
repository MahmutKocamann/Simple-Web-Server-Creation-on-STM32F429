# IAR project DMA2D_MemToMemWithBlending.ewp, settings and files
configuration DMA2D_MemToMemWithBlending (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F429_439xx; USE_STM32F429I_DISCO
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Utilities\STM32F429I-Discovery; $PROJ_DIR$C:\Users\Mahmut Kocaman\Desktop\STM32F429I\STM32F429I-Discovery_FW_V1.0.1\Projects\Peripheral_Examples\DMA2D_MemToMemWithBlending\EWARM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DMA2D_MemToMemWithBlending.srec
  ILINK.IlinkOutputFile: DMA2D_MemToMemWithBlending.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM
    ../../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f429_439xx.s
  group STM32F429I-Discovery
    ../../../../Utilities/STM32F429I-Discovery/: stm32f429i_discovery.c stm32f429i_discovery_lcd.c stm32f429i_discovery_sdram.c
  group STM32F4xx_StdPeriph_Driver
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_ltdc.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_usart.c
  group TM
    ../../../../../../../Downloads/stm32f429-master (1)/stm32f429-master/00-STM32F429_LIBRARIES/: attributes.h tm_stm32f4_delay.c tm_stm32f4_delay.h tm_stm32f4_disco.c tm_stm32f4_disco.h tm_stm32f4_dma.c tm_stm32f4_dma.h tm_stm32f4_fonts.c tm_stm32f4_fonts.h tm_stm32f4_gpio.c tm_stm32f4_gpio.h tm_stm32f4_ili9341.c tm_stm32f4_ili9341.h tm_stm32f4_spi.c tm_stm32f4_spi.h tm_stm32f4_spi_dma.c tm_stm32f4_spi_dma.h tm_stm32f4_usart.c tm_stm32f4_usart.h
  group User
    ../: main.c stm32f4xx_it.c system_stm32f4xx.c
